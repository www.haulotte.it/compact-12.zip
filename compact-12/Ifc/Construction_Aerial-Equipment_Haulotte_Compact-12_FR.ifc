Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView_V2.0]
File name: Numéro du projet
Time: 2019-12-09T21:17:31
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 20150220_1215(x64) - Exporter 16.6.0.0 - Interface alternative d'export 16.6.0.0
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Mon Dec 09 21:17:31 2019 * Host: N08 * Database: C:\Users\N~1\AppData\Local\Temp\{466E3D05-2127-4F6F-B255-F82296D36F71}\ifc * Database version: 5507 * Database creation date: Mon Dec 09 21:17:27 2019 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Mon Dec 09 21:17:27 2019 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Mon Dec 09 21:17:27 2019 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcProject, Numéro du projet
LongName: Nom du projet; Phase: Etat du projet

# IfcSite, Default
RefLatitude: 48, 51, 23, 999633; RefLongitude: 2, 21, 3, 553905; RefElevation: 0 m
Autre - Adresse du projet: Entrer l'adresse ici; Catégorie: Informations sur le projet; Date de fin du projet: Date de fin; Etat du projet: Etat du projet; Nom du client: Propriétaire; Nom du projet: Nom du projet; Numéro de projet: Numéro du projet

# IfcBuilding
Pset_BuildingCommon - NumberOfStoreys: 1
Autre - Catégorie: Informations sur le projet; Adresse du projet: Entrer l'adresse ici; Date de fin du projet: Date de fin; Etat du projet: Etat du projet; Nom du client: Propriétaire; Nom du projet: Nom du projet; Numéro de projet: Numéro du projet

# IfcBuildingStorey, Niveau 0
LongName: Niveau 0; Elevation: -1.94916e-14 m
Graphismes(Type) - Couleur: 12632256; Epaisseur des lignes: 1; Motif des lignes: Tiret point; Symbole: Marqueur de niveau - Point triangulaire: Marqueur de niveau - Point triangulaire; Valeur par défaut du symbole à l'extrémité 1: no; Valeur par défaut du symbole à l'extrémité 2: yes
Données d'identification(Type) - Nom du type: Ligne du Niveau
Contraintes(Type) - Base de l'élévation: Point de base du projet
Autre - Catégorie: Niveaux; Famille: Niveau: Ligne du Niveau; Famille et type: Niveau: Ligne du Niveau; ID du type: Niveau: Ligne du Niveau; Type: Niveau: Ligne du Niveau
Contraintes - Elévation: 0 m
Cotes - Hauteur de calcul: 0 m
Données d'identification - Etage de bâtiment: yes; Nom: Niveau 0; Structure: no
Autre(Type) - Catégorie: Niveaux; Nom de la famille: Niveau

# IfcBuildingElementProxy: Compact 12, Construction_Aerial-Equipment_Haulotte_Compact-12_FR:Compact 12:567290
In: Niveau 0
Type - Classification: E10 Equipement (Uniformat); Material: Metal - Haulotte - Black, Red, Metal - Haulotte - Grey Dark, Metal - Haulotte - Yellow, Metal - Haulotte - Grey, Metal - Haulotte - White
Type - Autre(Type) - Catégorie: Equipement spécialisé; Capacité Réservoir Huile Hydraulique: 75 l (20 gal); Masse Machine (CE): 4110 kg (9063 lbs); Nom de la famille: Construction_Aerial-Equipment_Haulotte_Compact-12_FR
Type - Données d'identification(Type) - Code d'assemblage: E10; Description: Capacité tout terrain remarquable 4 roues motrices Blocage différentiel automatique Excellente motricité (40%) Garde au sol de 28 cm Robustesse et facilité de maintenance Protections calages intégrées dans le gabarit Pupitre durable et fiable Accessibilité optimisée aux composants Outils d'auto-diagnostic intégré Productivité exceptionnelle Commandes entièrement proportionnelles Rayon de braquage étroit Calage centralisé à la descente comme à la montée; Description de l'assemblage: Equipement; Fabricant: Haulotte; Modèle: Compact 12; Nom du type: Compact 12; Note d'identification: 11000; Numéro OmniClass: 23.15.99.00; Product data url: https://www.bimobject.com/en/haulotte/product/compact-12; Titre OmniClass: Other Utility and Transportation Construction Products; URL: http://www.haulotte.fr
Type - Données(Type) - Capacité Maximum: 3 persons - 450 kg (3 persons - 1000 lbs); Empattement: 1,84 m ( 6 ft); Garde au Sol: 28 cm (11 in); Hauteur de Stockage: 1,7 m (5 ft 2 in); Hauteur Plateforme: 10,06 m (33 ft); Hauteur Repliée: 2,56 m (8 ft 5 in); Hauteur Travail: 12,06 m (39 ft); Largeur Hors Tout: 1,78 m (5 ft 10 in); Largeur Plateforme: 1,45 m (4 ft 9 in); Longueur Extension Plateforme: 1,2 m (3 ft 11 in); Longueur Hors Tout: 3,17 m (10 ft 5 in); Longueur Plateforme: 2,45 m (8 ft); Longueur Plateforme Étendue: 3,7 m (12 ft 2 in); Pente Maximum: 40%; Pneus: foam-filled tires 26 x 12 - 16,5; Pression Max au Sol: 6,1 daN/cm²; Rayon de Braquage Exterieur: 4,6 m (15 ft 1 in); Rayon de Braquage Interieur: 3,2 m (10 ft 6 in); Vitesse de Translation: 0,8-5,5 km/h (0,5-3,4 mph)
Type - Général(Type) - Edition number: 1
Pset_BuildingElementProxyCommon - Reference: Compact 12
Pset_ManufacturerTypeInformation - Manufacturer: Haulotte
Autre - Catégorie: Equipement spécialisé; Famille: Construction_Aerial-Equipment_Haulotte_Compact-12_FR: Compact 12; Famille et type: Construction_Aerial-Equipment_Haulotte_Compact-12_FR: Compact 12; H CTRL: 9.331 m; ID du type: Construction_Aerial-Equipment_Haulotte_Compact-12_FR: Compact 12; L: 1.06761 m; Type: Construction_Aerial-Equipment_Haulotte_Compact-12_FR: Compact 12
Construction - Abaque de Travail: no; Extension Plateforme: 1.175 m; Hauteur Maxi du Plancher sur Roue: 10 m; Rayon de Braquage Exterieur: no; Zone de Travail: no
Contraintes - Décalage: 0 m; Hôte: Niveau : Niveau 0; Niveau: Niveau: Niveau 0; Se déplace avec les éléments voisins: no
Cotes - Surface: 69.1667 m2; Volume: 10.2057 m3
Graphismes - Marque: yes
Phase de construction - Phase de création: Nouvelle construction
