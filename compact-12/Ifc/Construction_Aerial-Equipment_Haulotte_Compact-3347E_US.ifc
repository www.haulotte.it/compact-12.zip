Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView_V2.0]
File name: Numéro du projet
Time: 2019-12-09T21:21:03
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 20150220_1215(x64) - Exporter 16.6.0.0 - Interface alternative d'export 16.6.0.0
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Mon Dec 09 21:21:03 2019 * Host: N08 * Database: C:\Users\N~1\AppData\Local\Temp\{0F428677-EA9F-48F5-9584-E5D028DBB8CD}\ifc * Database version: 5507 * Database creation date: Mon Dec 09 21:20:58 2019 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Mon Dec 09 21:20:59 2019 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Mon Dec 09 21:20:59 2019 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcProject, Numéro du projet
LongName: Nom du projet; Phase: Etat du projet

# IfcSite, Default
RefLatitude: 48, 51, 23, 999633; RefLongitude: 2, 21, 3, 553905; RefElevation: 0 m
Autre - Adresse du projet: Entrer l'adresse ici; Catégorie: Informations sur le projet; Date de fin du projet: Date de fin; Etat du projet: Etat du projet; Nom du client: Propriétaire; Nom du projet: Nom du projet; Numéro de projet: Numéro du projet

# IfcBuilding
Pset_BuildingCommon - NumberOfStoreys: 1
Autre - Catégorie: Informations sur le projet; Adresse du projet: Entrer l'adresse ici; Date de fin du projet: Date de fin; Etat du projet: Etat du projet; Nom du client: Propriétaire; Nom du projet: Nom du projet; Numéro de projet: Numéro du projet

# IfcBuildingStorey, Niveau 0
LongName: Niveau 0; Elevation: -1.94916e-14 m
Graphismes(Type) - Couleur: 12632256; Epaisseur des lignes: 1; Motif des lignes: Tiret point; Symbole: Marqueur de niveau - Point triangulaire: Marqueur de niveau - Point triangulaire; Valeur par défaut du symbole à l'extrémité 1: no; Valeur par défaut du symbole à l'extrémité 2: yes
Données d'identification(Type) - Nom du type: Ligne du Niveau
Contraintes(Type) - Base de l'élévation: Point de base du projet
Autre - Catégorie: Niveaux; Famille: Niveau: Ligne du Niveau; Famille et type: Niveau: Ligne du Niveau; ID du type: Niveau: Ligne du Niveau; Type: Niveau: Ligne du Niveau
Contraintes - Elévation: 0 m
Cotes - Hauteur de calcul: 0 m
Données d'identification - Etage de bâtiment: yes; Nom: Niveau 0; Structure: no
Autre(Type) - Catégorie: Niveaux; Nom de la famille: Niveau

# IfcBuildingElementProxy: Compact 3347 E, Construction_Aerial-Equipment_Haulotte_Compact-3347E_US:Compact 3347 E:567290
In: Niveau 0
Type - Classification: E10 Equipement (Uniformat); Material: Metal - Haulotte - Black, Red, Metal - Haulotte - Grey Dark, Metal - Haulotte - Yellow, Metal - Haulotte - Grey, Metal - Haulotte - White
Type - Autre(Type) - Catégorie: Equipement spécialisé; Hydraulic System Capacity: 75 l (20 gal); Machine Weight: 4110 kg (9063 lbs); Nom de la famille: Construction_Aerial-Equipment_Haulotte_Compact-3347E_US
Type - Données d'identification(Type) - Code d'assemblage: E10; Description: Outstanding off-road capability 4 wheel drive Automatic differential loc Excellent motor skills (40% Ground clearance of 28 c Robustness and ease of maintenanc Shimming guards integrated in the templat Durable and reliable des Optimized accessibility to component Integrated self-diagnosis tool Exceptional productivit Fully proportional control Narrow turning radiu Centralized cushioning during the descent and ascen; Description de l'assemblage: Equipement; Fabricant: Haulotte; Modèle: Compact 3347 E; Nom du type: Compact 3347 E; Note d'identification: 11000; Numéro OmniClass: 23.15.99.00; Product data url: https://www.bimobject.com/haulotte/product/compact-12; Titre OmniClass: Other Utility and Transportation Construction Products; URL: http://www.haulotte-usa.com/
Type - Données(Type) - Drive Speed: 0,8-5,5 km/h (0,5-3,4 mph); Gradeability: 40%; Ground Clearance: 28 cm (11 in); Height - Stowed: 2,56 m (8 ft 5 in); Length: 3,17 m (10 ft 5 in); Lift Capacity: 3 persons - 450 kg (3 persons - 1000 lbs); Max Ground Pressure of Wheel on Paved Ground: 6,1 daN/cm²; Plateform Extension Length: 1,2 m (3 ft 11 in); Platform Height: 10,06 m (33 ft); Platform Length: 2,45 m (8 ft); Platform Length - Extended: 3,7 m (12 ft 2 in); Platform Width: 1,45 m (4 ft 9 in); Storage Height: 1,7 m (5 ft 2 in); Tires: foam-filled tires 26 x 12 - 16,5; Turning Radius - Inside: 3,2 m (10 ft 6 in); Turning Radius - Outside: 4,6 m (15 ft 1 in); Wheelbase: 1,84 m ( 6 ft); Width: 1,78 m (5 ft 10 in); Working Height: 12,06 m (39 ft)
Type - Général(Type) - Edition number: 1
Pset_BuildingElementProxyCommon - Reference: Compact 3347 E
Pset_ManufacturerTypeInformation - Manufacturer: Haulotte
Autre - Catégorie: Equipement spécialisé; Famille: Construction_Aerial-Equipment_Haulotte_Compact-3347E_US: Compact 3347 E; Famille et type: Construction_Aerial-Equipment_Haulotte_Compact-3347E_US: Compact 3347 E; H CTRL: 9.331 m; ID du type: Construction_Aerial-Equipment_Haulotte_Compact-3347E_US: Compact 3347 E; L: 1.06761 m; Type: Construction_Aerial-Equipment_Haulotte_Compact-3347E_US: Compact 3347 E
Construction - Extension Desk Length: 1.175 m; Maximum Platform Height on Wheel: 10 m; Reach Diagram: no; Turning Radius: no; Working Area: no
Contraintes - Décalage: 0 m; Hôte: Niveau : Niveau 0; Niveau: Niveau: Niveau 0; Se déplace avec les éléments voisins: no
Cotes - Surface: 69.1839 m2; Volume: 10.2058 m3
Graphismes - Branding: yes
Phase de construction - Phase de création: Nouvelle construction
